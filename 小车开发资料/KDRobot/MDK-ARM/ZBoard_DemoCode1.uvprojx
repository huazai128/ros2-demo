# Keil uVision project ZBoard_DemoCode1.uvprojx, settings and files
target ZBoard_DemoCode1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ZBoard_DemoCode1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\Core\Oled; ..\Core\Gui; ..\Core\Font; ..\Core\Comm
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group OLED
    ../Core/Oled/: oled.c
  group GUI
    ../Core/Gui/: SOLGUI_Common.c SOLGUI_GBasic.c SOLGUI_Hardware.c SOLGUI_Menu.c SOLGUI_Picture.c SOLGUI_Printf.c SOLGUI_Widget.c
  group Font
    ../Core/Font/: Font4x6_ASCII.c Font6x8_ASCII.c Font8x8_ASCII.c Font8x10_ASCII.c
  group Comm
    ../Core/Comm/: comm.c
software components: CMSIS:CORE 4.3.0
